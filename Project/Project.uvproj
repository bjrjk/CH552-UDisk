# Keil uVision project Project.uvproj, settings and files
target CH552UDisk (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: Pro +hex
  AfterMake: hex2bin "#H"
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\
  link misc: REMOVEUNUSED
  group User
    ../: Debug.C Main.C
